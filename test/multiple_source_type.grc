<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>multiplier</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>multiplier</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>redhawk_integration_redhawk_sink</key>
<param><key>id</key><value>redhawk_integration_redhawk_sink_0</value></param>
<param><key>corba_namespace_name</key><value></value></param>
<param><key>naming_context_ior</key><value></value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>redhawk_integration_redhawk_sink</key>
<param><key>id</key><value>redhawk_integration_redhawk_sink_1</value></param>
<param><key>corba_namespace_name</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>naming_context_ior</key><value></value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>redhawk_integration_redhawk_source</key>
<param><key>id</key><value>redhawk_integration_redhawk_source_0</value></param>
<param><key>corba_namespace_name</key><value></value></param>
<param><key>naming_context_ior</key><value></value></param>
<param><key>type</key><value>int</value></param>
<param><key>packet_depth</key><value>10</value></param>
</block>
<block>
<key>redhawk_integration_redhawk_source</key>
<param><key>id</key><value>redhawk_integration_redhawk_source_1</value></param>
<param><key>corba_namespace_name</key><value></value></param>
<param><key>naming_context_ior</key><value></value></param>
<param><key>type</key><value>float</value></param>
<param><key>packet_depth</key><value>10</value></param>
</block>
<block>
<key>redhawk_integration_redhawk_source</key>
<param><key>id</key><value>redhawk_integration_redhawk_source_2</value></param>
<param><key>corba_namespace_name</key><value></value></param>
<param><key>naming_context_ior</key><value></value></param>
<param><key>type</key><value>float</value></param>
<param><key>packet_depth</key><value>10</value></param>
</block>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1</source_block_id><sink_block_id>redhawk_integration_redhawk_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1</source_block_id><sink_block_id>redhawk_integration_redhawk_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>redhawk_integration_redhawk_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>redhawk_integration_redhawk_source_1</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>redhawk_integration_redhawk_source_2</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
