<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>example_fg_3</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>copy_of_random</value></param>
<param><key>value</key><value>random_variable</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>label_integer</value></param>
<param><key>value</key><value>1337</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>label_string</value></param>
<param><key>value</key><value>hello</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>label_true</value></param>
<param><key>value</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>random_variable</value></param>
<param><key>value</key><value>123456789</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>samp_rate_clone</value></param>
<param><key>value</key><value>samp_rate</value></param>
<param><key>label</key><value>uses_samp_rate</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>2</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>redhawk_integration_redhawk_sink</key>
<param><key>id</key><value>redhawk_integration_redhawk_sink_0</value></param>
<param><key>corba_namespace_name</key><value></value></param>
<param><key>naming_context_ior</key><value></value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>redhawk_integration_redhawk_source</key>
<param><key>id</key><value>redhawk_integration_redhawk_source_0</value></param>
<param><key>corba_namespace_name</key><value></value></param>
<param><key>naming_context_ior</key><value></value></param>
<param><key>type</key><value>short</value></param>
<param><key>packet_depth</key><value>10</value></param>
</block>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>redhawk_integration_redhawk_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>redhawk_integration_redhawk_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
