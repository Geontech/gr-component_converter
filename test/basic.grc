<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>basic</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>redhawk_integration_redhawk_sink</key>
<param><key>id</key><value>redhawk_integration_redhawk_sink_0</value></param>
<param><key>corba_namespace_name</key><value></value></param>
<param><key>naming_context_ior</key><value></value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>redhawk_integration_redhawk_source</key>
<param><key>id</key><value>redhawk_integration_redhawk_source_0</value></param>
<param><key>corba_namespace_name</key><value></value></param>
<param><key>naming_context_ior</key><value></value></param>
<param><key>type</key><value>short</value></param>
<param><key>packet_depth</key><value>10</value></param>
</block>
<connection><source_block_id>redhawk_integration_redhawk_source_0</source_block_id><sink_block_id>redhawk_integration_redhawk_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
